## Kconfig
```kconfig
config VMMCLOCK
       bool "OpenBSD VMM hypervisor clocksouce"
       depends on KVM
       default m
       help
         TBD
```
